# Repository juddmehr/projects

File README.md:

# Personal Projects Repository

## [Corne Keyboards](corne-keyboards)

## [Discus Launch Glider](discus-launch-glider)

## [Pipsqueak Air Engine](pipsqueak-engine)

## [Swiss Army Knife Scales](swiss-army-knife-scales)

## [Blazer Buttons](blazer-buttons)

## [Business Card Holder](business-card-holder)

## KiCad design pcb_files/modified_corne-cherry_files/corne-cherry.kicad_pcb

File pcb_files/README.md:

# PCB File Notes

Production_Files.zip are the exact files I sent to [https://jlcpcb.com/](https://jlcpcb.com/) for manufacture.  I changed almost nothing from [foostan's files](https://github.com/foostan/crkbd/tree/main/corne-cherry/pcb) except the [front silks](modified_files_from_foostan/svg/corne-cherry-F_SilkS.pdf).  I've also included here the files I modified from the [original corne-cherry files](https://github.com/foostan/crkbd/tree/main/corne-cherry/pcb).

NOTE: I had to 3D print ["plugs"]() in order to get my standoffs to work the way I wanted.  If I were to redo things, I'd change the holes to be 2.4mm diamter to work with the screws and standoffs I used (i.e., make the 5 support holes the same size as the 2 holes for the OLED cover).  In the official [build guide](https://github.com/foostan/crkbd/blob/main/corne-cherry/doc/v3/buildguide_en.md), it is recomended to use spacers, but I wanted a slightly more secure solution.

Board: 2 copper layers, 275.5 x 105.6 mm, 160 parts (99 on the bottom side), 128 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42: D; D3_SMD_v2
J1, J3: MJ-4PP-9; MJ-4PP-9_1side
J2, J4: OLED; OLED_1side
LED1, LED2, LED3, LED4, LED5, LED6, LED28, LED29, LED30, LED31, LED32, LED33: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54: YS-SK6812MINI-E
RSW1, RSW2: SW_PUSH; ResetSW_1side
Ref**: Val**; M2_HOLE_v2
Ref**#2, Ref**#3, Ref**#4, Ref**#5, Ref**#6, Ref**#7, Ref**#8, Ref**#9, Ref**#10, Ref**#11, Ref**#12, Ref**#13, Ref**#14: Val**; M2_HOLE_v2
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41: SW_PUSH; CherryMX_Hotswap
SW21, SW42: SW_PUSH; CherryMX_Hotswap_1.5u
U1, U2: ProMicro; ProMicro_v3

Connections:
GND: J1.C, J2.4, LED1.3, LED2.3, LED3.3, LED4.3, LED5.3, LED6.3, LED7.3, LED8.3, LED9.3, LED10.3, LED11.3, LED12.3, LED13.3, LED14.3, LED15.3, LED16.3, LED17.3, LED18.3, LED19.3, LED20.3, LED21.3, LED22.3, LED23.3, LED24.3, LED25.3, LED26.3, LED27.3, RSW1.2, U1.3, U1.4, U1.23
GNDA: J3.C, J4.4, LED28.3, LED29.3, LED30.3, LED31.3, LED32.3, LED33.3, LED34.3, LED35.3, LED36.3, LED37.3, LED38.3, LED39.3, LED40.3, LED41.3, LED42.3, LED43.3, LED44.3, LED45.3, LED46.3, LED47.3, LED48.3, LED49.3, LED50.3, LED51.3, LED52.3, LED53.3, LED54.3, RSW2.2, U2.3, U2.4, U2.23
LED: LED3.4, U1.1
LED_r: LED30.4, U2.1
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: D22.2, SW22.2
unnamed: D23.2, SW23.2
unnamed: D24.2, SW24.2
unnamed: D25.2, SW25.2
unnamed: D26.2, SW26.2
unnamed: D27.2, SW27.2
unnamed: D28.2, SW28.2
unnamed: D29.2, SW29.2
unnamed: D30.2, SW30.2
unnamed: D31.2, SW31.2
unnamed: D32.2, SW32.2
unnamed: D33.2, SW33.2
unnamed: D34.2, SW34.2
unnamed: D35.2, SW35.2
unnamed: D36.2, SW36.2
unnamed: D37.2, SW37.2
unnamed: D38.2, SW38.2
unnamed: D39.2, SW39.2
unnamed: D40.2, SW40.2
unnamed: D41.2, SW41.2
unnamed: D42.2, SW42.2
unnamed: LED1.2, LED4.4
unnamed: LED1.4, LED2.2
unnamed: LED2.4, LED3.2
unnamed: LED4.2, LED5.4
unnamed: LED5.2, LED6.4
unnamed: LED7.4, LED8.2
unnamed: LED9.4, LED10.2
unnamed: LED10.4, LED16.2
unnamed: LED11.2, LED17.4
unnamed: LED11.4, LED12.2
unnamed: LED12.4, LED18.2
unnamed: LED13.2, LED19.4
unnamed: LED7.2, LED13.4
unnamed: LED8.4, LED14.2
unnamed: LED14.4, LED20.2
unnamed: LED15.2, LED21.4
unnamed: LED9.2, LED15.4
unnamed: LED16.4, LED22.2
unnamed: LED17.2, LED23.4
unnamed: LED18.4, LED24.2
unnamed: LED20.4, LED21.2
unnamed: LED22.4, LED25.2
unnamed: LED23.2, LED26.4
unnamed: LED24.4, LED27.2
unnamed: LED25.4, LED26.2
unnamed: LED6.2, LED27.4
unnamed: LED28.2, LED31.4
unnamed: LED28.4, LED29.2
unnamed: LED29.4, LED30.2
unnamed: LED31.2, LED32.4
unnamed: LED32.2, LED33.4
unnamed: LED33.2, LED54.4
unnamed: LED34.2, LED40.4
unnamed: LED34.4, LED35.2
unnamed: LED35.4, LED41.2
unnamed: LED36.2, LED42.4
unnamed: LED36.4, LED37.2
unnamed: LED37.4, LED43.2
unnamed: LED38.2, LED44.4
unnamed: LED38.4, LED39.2
unnamed: LED39.4, LED45.2
unnamed: LED40.2, LED46.4
unnamed: LED41.4, LED47.2
unnamed: LED42.2, LED48.4
unnamed: LED43.4, LED49.2
unnamed: LED44.2, LED50.4
unnamed: LED45.4, LED51.2
unnamed: LED47.4, LED48.2
unnamed: LED49.4, LED52.2
unnamed: LED50.2, LED53.4
unnamed: LED51.4, LED54.2
unnamed: LED52.4, LED53.2
SCL: J2.2, U1.6
SCL_r: J4.2, U2.6
SDA: J2.1, U1.5
SDA_r: J4.1, U2.5
VCC: J1.D, J2.3, LED1.1, LED2.1, LED3.1, LED4.1, LED5.1, LED6.1, LED7.1, LED8.1, LED9.1, LED10.1, LED11.1, LED12.1, LED13.1, LED14.1, LED15.1, LED16.1, LED17.1, LED18.1, LED19.1, LED20.1, LED21.1, LED22.1, LED23.1, LED24.1, LED25.1, LED26.1, LED27.1, U1.21
VDD: J3.D, J4.3, LED28.1, LED29.1, LED30.1, LED31.1, LED32.1, LED33.1, LED34.1, LED35.1, LED36.1, LED37.1, LED38.1, LED39.1, LED40.1, LED41.1, LED42.1, LED43.1, LED44.1, LED45.1, LED46.1, LED47.1, LED48.1, LED49.1, LED50.1, LED51.1, LED52.1, LED53.1, LED54.1, U2.21
col0: SW1.1, SW7.1, SW13.1, U1.20
col0_r: SW22.1, SW28.1, SW34.1, U2.20
col1: SW2.1, SW8.1, SW14.1, U1.19
col1_r: SW23.1, SW29.1, SW35.1, U2.19
col2: SW3.1, SW9.1, SW15.1, U1.18
col2_r: SW24.1, SW30.1, SW36.1, U2.18
col3: SW4.1, SW10.1, SW16.1, SW19.1, U1.17
col3_r: SW25.1, SW31.1, SW37.1, SW40.1, U2.17
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16
col4_r: SW26.1, SW32.1, SW38.1, SW41.1, U2.16
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15
col5_r: SW27.1, SW33.1, SW39.1, SW42.1, U2.15
data: J1.B, U1.2
data_r: J3.B, U2.2
reset: RSW1.1, U1.22
reset_r: RSW2.1, U2.22
row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, U1.7
row0_r: D22.1, D23.1, D24.1, D25.1, D26.1, D27.1, U2.7
row1: D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, U1.8
row1_r: D28.1, D29.1, D30.1, D31.1, D32.1, D33.1, U2.8
row2: D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, U1.9
row2_r: D34.1, D35.1, D36.1, D37.1, D38.1, D39.1, U2.9
row3: D19.1, D20.1, D21.1, U1.10
row3_r: D40.1, D41.1, D42.1, U2.10

## Commit log

2022-02-28 init
2022-02-28 add pcb files
2022-02-28 add images
2022-02-28 Create LICENSE
2022-02-28 add files
2022-02-28 Rename LICENSE to original_LICENSE
2022-02-28 update links
2022-03-01 first draft
2022-03-16 add case and plate files
2022-03-16 fix names
2022-11-19 reorganize
2022-11-19 start adding more projects
2022-11-19 udpate readme
2024-07-25 add placeholders for recent projects
2024-07-26 add pictures
2024-07-26 update photo
2024-07-26 test html
2024-07-26 resize image
2024-07-26 resize images
2024-07-26 link cad files
2024-07-26 fix typo
2024-07-26 add description
2024-07-26 update descriptions
2025-01-06 add recent project files
2025-01-24 add trackball files
2025-01-24 ignore DSstore files
